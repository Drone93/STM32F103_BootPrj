# Keil uVision project stm32f103_bootloader_prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_bootloader_prj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\0inc;.\STM32_USB_CDC_libs;.\0inc\inc
  memory RVCT4: ROM 0x8018000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./0src/: stm32_delay_asm.c TFT_SPI.c
  group Boot_Main
    ./: btldr_main.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0
